# Kernel console on the Pi 5 debug UART connector; GPIO14/15 (ttyAMA0) is used by the GPS
CMDLINE_SERIAL = "console=ttyAMA10,115200"
