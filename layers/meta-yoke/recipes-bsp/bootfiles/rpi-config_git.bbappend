# UART on GPIO14/15 (/dev/ttyAMA0) for the GPS
RPI_EXTRA_CONFIG:append = "\ndtparam=uart0=on"
