# Custom /etc/network/interfaces: brings wlan0 up automatically
FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
